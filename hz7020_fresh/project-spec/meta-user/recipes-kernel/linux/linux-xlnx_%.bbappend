FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRCTREECOVEREDTASKS_remove = "do_kernel_configme do_patch"
